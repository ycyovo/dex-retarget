Commit message: feat: angle limit

File: assets/robots/hands/allegro_hand/allegro_hand_right.urdf (robot description, URDF)
Before this commit: robot allegro_right, 23 links, 22 joints
Links:
- link palm: mass None -> 1e-6
- link wrist: mass None -> 1e-6
